# IAR project f3.ewp, settings and files
configuration f3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xE; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include; ..\..\bsp; ..\..\library; ..\..\modules\debug; ..\..\modules\flashfs; ..\..\library\misc; ..\..\library\dsp; ..\..\library\cplusplus; ..\..\modules\uperf; ..\..\library\control; ..\..\modules\ipc; ..\..\library\ringbuffer; ..\..\library\canard\dsdlc_generated; ..\..\library\canard; ..\..\src; ..\..\library\queue; ..\..\modules\param; ..\..\modules\mavlink; ..\..\library\uthash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: f3.hex
  ILINK.IlinkOutputFile: f3.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\library\dsp\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303xe.s
  group Application/User/Core
    ../Core/Src/: adc.c can.c dma.c freertos.c gpio.c main.c spi.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c stm32f3xx_it.c tim.c usart.c
  group BSP
    ../../bsp/: amt222.c delay.c hrt_timer.c platform_f3.c serial.c uavcan.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Library/cplusplus
    ../../library/cplusplus/: crt.cpp
  group Library/misc
    ../../library/misc/: crc32.c utils.c
  group Library/pid
    ../../library/control/pid/: pid.cpp
  group Library/queue
    ../../library/queue/: dq_addafter.c dq_addbefore.c dq_addfirst.c dq_addlast.c dq_cat.c dq_count.c dq_rem.c dq_remfirst.c dq_remlast.c sq_addafter.c sq_addfirst.c sq_addlast.c sq_cat.c sq_count.c sq_rem.c sq_remafter.c sq_remfirst.c sq_remlast.c
  group Library/ringbuffer
    ../../library/ringbuffer/: ringbuffer.c ringbuffer_cpp.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Modules/debug
    ../../modules/debug/: SEGGER_RTT.c SEGGER_RTT_Printf.c
  group Modules/flashfs
    ../../modules/flashfs/: flashfs.c tinybson.c
  group Modules/ipc
    ../../modules/ipc/: ipc.cpp ipchelper.cpp ipcmain.cpp topics_common.cpp
  group Modules/ipc/topics
    ../../modules/ipc/topics/: actuator_notify.h calibrate_status.h encoder.h foc_command.h foc_status.h parameter_update.h telemetry_status.h uavcan_command_request.h uavcan_command_response.h uavcan_parameter_request.h uavcan_parameter_value.h
  group Modules/mavlink
    ../../modules/mavlink/: mavlink_logs.cpp
  group Modules/param
    ../../modules/param/: foc_parameter.c param.c
  group Modules/uperf
    ../../modules/uperf/: uPerf.c
  group Src
    ../../src/: startup_task.c
  group Src/canlink
    ../../src/uavcan/: canlink.cpp
  group Src/command
    ../../src/command/: command.cpp elec_calibration.cpp mech_calibration.cpp
  group Src/encoder
    ../../src/encoder/: encoder.cpp
  group Src/foc
    ../../src/foc/: foc.cpp
  group Src/notify
    ../../src/notify/: led.cpp
  group Src/shell
    ../../src/shell/: shell.cpp
  group Src/telemetry
    ../../src/telemetry/: mavlink_main.cpp mavlink_messages.cpp mavlink_orb_subscription.cpp mavlink_parameters.cpp mavlink_receiver.cpp mavlink_stream.cpp
